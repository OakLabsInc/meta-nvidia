include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

SRC_URI[md5sum] = "43ef230649f2fec23efb340653e72265"
SRC_URI[sha256sum] = "a7b7984fc532be17c262bc4353e279824ae63625d8ae9f1016cb66d199b97650"
