include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

SRC_URI[md5sum] = "0f42f6706da80d32574371c8a0894e60"
SRC_URI[sha256sum] = "7b53bdee6e396cb271b57f77455fe5c561e655ca3fbba015dae0de3d6c11542b"
