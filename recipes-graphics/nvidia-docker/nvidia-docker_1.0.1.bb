include nvidia-docker.inc

SRCREV = "01d2c9436620d7dde4672e414698afe6da4a282f"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e144bfb48f3db70813d05f1d37b39400"
