include nvidia-docker-compose.inc

SRCREV = "8903362599a795e37d998ba92574ed947f028707"
LIC_FILES_CHKSUM = "file://setup.py;md5=463189e2f2b1abc0f75de9b953da0545"
