include libglvnd.inc

SRCREV = "a14972089e27d6c191491d8287bc283790a5d74d"
